Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-28T23:57:18
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181011_1545(x64) - Exporter 17.0.511.0 - Альтернативный интерфейс 17.14.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 28 23:57:18 2020 * Host: 189-i7-2600k * Database: C:\Users\EAD1D~1.PID\AppData\Local\Temp\{870D80F5-0463-4572-A85F-304902568B82}\ifc * Database version: 5507 * Database creation date: Mon Sep 28 23:57:13 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 28 23:57:14 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 28 23:57:14 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuilding
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Вариант конструкции: Главная модель; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Базовая отметка: Базовая точка проекта; Фасад: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Размеры - Расчетная высота: 0 mm

# IfcEnergyConversionDevice: XXL ECO 1050, BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600:XXL ECO 1050:655978
In: Этаж 01
Type - PredefinedType: WATER; Material: Color RGB 120-120-120, Color RGB 216-216-216, Color RGB 255-255-240, Color RGB 181-181-181, Color RGB 100-100-100, Color RGB 049-049-049
Type - Видимость - Газ_Фланец: yes
Type - Графика - Зона обслуживания_Глубина_Задняя часть: 450 mm; Зона обслуживания_Глубина_Левая сторона: 800 mm; Зона обслуживания_Глубина_Лицевая часть: 1000 mm; Зона обслуживания_Глубина_Правая сторона: 450 mm; Привязка_Зона обслуживания_Задняя часть: 550 mm
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: ELCO; ADSK_Код изделия: 3581761; ADSK_Марка: TRIGON XXL ECO 1050; ADSK_Наименование: Водотрубный премиксный конденсационный котел TRIGON XXL ECO, 1003 кВт, максимальное давление 8 Бар; ELCO_Страна производства: Нидерланды
Type - Идентификация - ADSK_URL документации изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_URL страницы изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.pro/manufacturer/company/16987; BL_Email: support@ru.elco.net; BL_Разработано: support@bimlib.pro; URL: https://elco.net.ru/; Заголовок OmniClass: Hot Water Heat Generators; Изготовитель: ELCO Heating Solutions; Имя типа: XXL ECO 1050; Номер OmniClass: 23.75.10.11.14; Описание: Высокоэффективные водотрубные премиксные котлы TRIGON XXL с уникальной модулируемой водоохлаждаемой горелкой. TRIGON XXL ECO – конденсационные котлы с эффективностью до 104,1 %
Type - Механизмы - Гидравлическое сопротивление при номинальном расходе ΔT=20: 42000 Pa; Давление воды макс: 800000 Pa; Давление воды мин: 150000 Pa; Максимальная рабочая температура: 90 kg/K/s3; Максимальная разница температур между подающей и обратной линией: 30 kg/K/s3; Номинальный расход при ΔT=20: 0.0119444 m3/s; Объем воды: 0.085 m3
Type - Механизмы - Нагрузки - Минимальная тепловая мощность при 50⁄30 ⁰С: 298000 W; Минимальная тепловая мощность при 80⁄60 ⁰С: 285000 W; Номинальная тепловая мощность при 50⁄30 ⁰С: 1074000 W; Номинальная тепловая мощность при 80⁄60 ⁰С: 1003000 W; Номинальная тепловая нагрузка макс: 1066000 W; Номинальная тепловая нагрузка мин: 305000 W; Эффективность на макс при 50⁄30 ⁰С: 0.949; Эффективность на макс при 80⁄60 ⁰С: 0.941; Эффективность на мин при 50⁄30 ⁰С: 1.029; Эффективность на мин при 80⁄60 ⁰С: 0.934
Type - Механизмы - Расход - Максимальное давление газа: 10000 Pa; Максимальный расход газа: 0.0318264 m3/s; Минимальное давление природного газа G20: 1700 Pa; Минимальное давление природного газа G25: 2000 Pa; Минимальное давление СУГ G31: 3000 Pa; Минимальный расход газа: 0.00910605 m3/s; Номинальное давление природного газа G20: 2000 Pa; Номинальное давление природного газа G25: 2500 Pa; Номинальное давление СУГ G31: 3000 Pa; Фактическая калорийность газа: 8000
Type - Прочее - Категория: Оборудование; Имя семейства: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600; Максимальный объемный расход конденсата: 12.7 Л/ч; Максимальный остаточный напор дымовых газов после котла: 150 Pa; Максимальный уровень CO: 4 мг/кВт∙ч; Максимальный уровень NOx: 37 мг/кВт∙ч; Макс температура дымовых газов при 80⁄60 ⁰С: 153 kg/K/s3; Массовый расход дымовых газов макс: 1694 кг/ч; Массовый расход дымовых газов мин: 528 кг/ч; Объемный расход дымовых газов макс: 0.567778 m3/s; Объемный расход дымовых газов мин: 0.137778 m3/s
Type - Размеры - Горелка 1: yes; Горелка 2: no; Соединитель 1: yes; Соединитель 1 Длина: 0 mm; Соединитель 2: no; ADSK_Размер_Высота: 1555 mm; ADSK_Размер_Глубина: 2565 mm; ADSK_Размер_Ширина: 1370 mm; B1: 1275 mm; B2: 685 mm; B3: 95 mm; B4: 1160 mm; B5: 100 mm; B6: 1180 mm; D: 400 mm; G: 76 mm; H1: 960 mm; H2: 660 mm; H3: 530 mm; H4: 500 mm; L1: 480 mm; L2: 1030 mm; L3: 260 mm; L4: 110 mm; L5: 550 mm; LW: 185 mm; W: 89 mm; Высота G: 500 mm; Высота W: 660 mm; Высота дымовых газов: 530 mm; Высота слива: 272 mm; Глубина блока: 2085 mm; Диаметр компенсатора: 250 mm; Длина 1_1: 678.5 mm; Длина 1_2: 674 mm; Длина 1_3: 1 mm; Длина 2_1: 968 mm; Длина 2_2: 1 mm; Длина 2_З: 1 mm; Длина 3_1: 1933 mm; Длина 3_2: 1 mm; Длина отрезка: 326 mm; Подключение воды: 80 mm; Подключение газа: 65 mm; Подключение дымохода: 400 mm; Подключение забора воздуха_для внешнего забора: 355 mm; Подключение слива конденсата: 40 mm; Радиус компенсатора: 127 mm; Служебная подрезка: 18 mm; Смещение: 94 mm; Смещение ножек: 1324 mm; Смещение соединения воды: 1225 mm; Соединитель 2 Длина: 480 mm; Ширина G: 100 mm; Ширина W: 1275 mm; Ширина дымовых газов: 260 mm; Ширина полки Горелки: 778.5 mm; Ширина слива: 645 mm
Type - Силы - Уровень звуковой мощности: 68.7 дБ(А)
Type - Текст - ADSK_Масса: 1369
Type - Электросети - Класс защиты от поражения электрическим током: IP00; Потребляемая котлом электрическая мощность макс: 1270 W; Потребляемая котлом электрическая мощность мин: 320 W; Предохранитель: 16 A; Частота: 50 Hz
Type - Электросети - Нагрузки - ADSK_Количество фаз: 1; ADSK_Напряжение: 400 V
Видимость - Зона обслуживания: no; Контрфланец: no
Зависимости - Смещение: 0 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 41
Механизмы - ELCO_Слив: 0; ADSK_Расход воздуха приточный: 0 m3/s; ADSK_Расход жидкости: 0 m3/s; ELCO_Отвод дымовых газов: 0 m3/s; ELCO_Расход газа: 0 m3/s; Классификация систем: Приточный воздух,Мощность,Не определено,Обратная жидкость,Приточная жидкость,Канализация,Отработанный воздух
Прочее - Код типа: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600: XXL ECO 1050; Семейство: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600: XXL ECO 1050; Семейство и типоразмер: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600: XXL ECO 1050; Тип: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600: XXL ECO 1050
Размеры - Смещение водяного соединителя: 0 mm; Объем: 4.07972 m3; Смещение фланца: 45 mm
Стадии - Стадия возведения: Стадия 1

# IfcEnergyConversionDevice: XXL ECO 1150, BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600:XXL ECO 1150:655986
In: Этаж 01
Type - PredefinedType: WATER; Material: Color RGB 120-120-120, Color RGB 216-216-216, Color RGB 255-255-240, Color RGB 181-181-181, Color RGB 100-100-100, Color RGB 049-049-049
Type - Видимость - Газ_Фланец: yes
Type - Графика - Зона обслуживания_Глубина_Задняя часть: 450 mm; Зона обслуживания_Глубина_Левая сторона: 800 mm; Зона обслуживания_Глубина_Лицевая часть: 1000 mm; Зона обслуживания_Глубина_Правая сторона: 450 mm; Привязка_Зона обслуживания_Задняя часть: 710 mm
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: ELCO; ADSK_Код изделия: 3581762; ADSK_Марка: TRIGON XXL ECO 1150; ADSK_Наименование: Водотрубный премиксный конденсационный котел TRIGON XXL ECO, 1097 кВт, максимальное давление 8 Бар; ELCO_Страна производства: Нидерланды
Type - Идентификация - ADSK_URL документации изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_URL страницы изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.pro/manufacturer/company/16987; BL_Email: support@ru.elco.net; BL_Разработано: support@bimlib.pro; URL: https://elco.net.ru/; Заголовок OmniClass: Hot Water Heat Generators; Изготовитель: ELCO Heating Solutions; Имя типа: XXL ECO 1150; Номер OmniClass: 23.75.10.11.14; Описание: Высокоэффективные водотрубные премиксные котлы TRIGON XXL с уникальной модулируемой водоохлаждаемой горелкой. TRIGON XXL ECO – конденсационные котлы с эффективностью до 104,1 %
Type - Механизмы - Гидравлическое сопротивление при номинальном расходе ΔT=20: 68000 Pa; Давление воды макс: 800000 Pa; Давление воды мин: 150000 Pa; Максимальная рабочая температура: 90 kg/K/s3; Максимальная разница температур между подающей и обратной линией: 30 kg/K/s3; Номинальный расход при ΔT=20: 0.00472222 m3/s; Объем воды: 0.097 m3
Type - Механизмы - Нагрузки - Минимальная тепловая мощность при 50⁄30 ⁰С: 328000 W; Минимальная тепловая мощность при 80⁄60 ⁰С: 311000 W; Номинальная тепловая мощность при 50⁄30 ⁰С: 1185000 W; Номинальная тепловая мощность при 80⁄60 ⁰С: 1097000 W; Номинальная тепловая нагрузка макс: 1166000 W; Номинальная тепловая нагрузка мин: 333000 W; Эффективность на макс при 50⁄30 ⁰С: 0.949; Эффективность на макс при 80⁄60 ⁰С: 0.941; Эффективность на мин при 50⁄30 ⁰С: 1.029; Эффективность на мин при 80⁄60 ⁰С: 0.934
Type - Механизмы - Расход - Максимальное давление газа: 10000 Pa; Максимальный расход газа: 0.034812 m3/s; Минимальное давление природного газа G20: 3500 Pa; Минимальное давление природного газа G25: 3500 Pa; Минимальное давление СУГ G31: 5000 Pa; Минимальный расход газа: 0.00994202 m3/s; Номинальное давление природного газа G20: 3500 Pa; Номинальное давление природного газа G25: 3500 Pa; Номинальное давление СУГ G31: 5000 Pa; Фактическая калорийность газа: 8000
Type - Прочее - Категория: Оборудование; Имя семейства: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600; Максимальный объемный расход конденсата: 13.9 Л/ч; Максимальный остаточный напор дымовых газов после котла: 150 Pa; Максимальный уровень CO: 4 мг/кВт∙ч; Максимальный уровень NOx: 37 мг/кВт∙ч; Макс температура дымовых газов при 80⁄60 ⁰С: 153 kg/K/s3; Массовый расход дымовых газов макс: 1853 кг/ч; Массовый расход дымовых газов мин: 576 кг/ч; Объемный расход дымовых газов макс: 0.621111 m3/s; Объемный расход дымовых газов мин: 0.149722 m3/s
Type - Размеры - ADSK_Размер_Высота: 1555 mm; ADSK_Размер_Глубина: 2795 mm; ADSK_Размер_Ширина: 1570 mm; B1: 1445 mm; B2: 785 mm; B3: 145 mm; B4: 1360 mm; B5: 145 mm; B6: 1300 mm; D: 450 mm; G: 76 mm; H1: 895 mm; H2: 420 mm; H3: 470 mm; H4: 240 mm; L1: 480 mm; L2: 1030 mm; L3: 350 mm; L4: 230 mm; L5: 710 mm; LW: 185 mm; W: 89 mm; Высота G: 420 mm; Высота W: 240 mm; Высота дымовых газов: 470 mm; Высота слива: 161 mm; Глубина блока: 2085 mm; Горелка 1: no; Горелка 2: yes; Диаметр компенсатора: 250 mm; Длина 1_1: 678.5 mm; Длина 1_2: 674 mm; Длина 1_3: 1 mm; Длина 2_1: 968 mm; Длина 2_2: 1 mm; Длина 2_З: 1 mm; Длина 3_1: 1933 mm; Длина 3_2: 1 mm; Длина отрезка: 325 mm; Подключение воды: 80 mm; Подключение газа: 65 mm; Подключение дымохода: 450 mm; Подключение забора воздуха_для внешнего забора: 450 mm; Подключение слива конденсата: 40 mm; Радиус компенсатора: 127 mm; Служебная подрезка: 18 mm; Смещение: 94 mm; Смещение ножек: 1524 mm; Смещение соединения воды: 1225 mm; Соединитель 1: no; Соединитель 1 Длина: 480 mm; Соединитель 2: yes; Соединитель 2 Длина: 0 mm; Ширина G: 1445 mm; Ширина W: 145 mm; Ширина дымовых газов: 350 mm; Ширина полки Горелки: 859.4 mm; Ширина слива: 105 mm
Type - Силы - Уровень звуковой мощности: 68.7 дБ(А)
Type - Текст - ADSK_Масса: 1380
Type - Электросети - Класс защиты от поражения электрическим током: IP00; Потребляемая котлом электрическая мощность макс: 2330 W; Потребляемая котлом электрическая мощность мин: 585 W; Предохранитель: 16 A; Частота: 50 Hz
Type - Электросети - Нагрузки - ADSK_Количество фаз: 1; ADSK_Напряжение: 400 V
Видимость - Зона обслуживания: no; Контрфланец: no
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 42
Механизмы - ELCO_Слив: 0; ADSK_Расход воздуха приточный: 0 m3/s; ADSK_Расход жидкости: 0 m3/s; ELCO_Отвод дымовых газов: 0 m3/s; ELCO_Расход газа: 0 m3/s; Классификация систем: Приточный воздух,Мощность,Не определено,Обратная жидкость,Приточная жидкость,Канализация,Отработанный воздух
Прочее - Код типа: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600: XXL ECO 1150; Семейство: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600: XXL ECO 1150; Семейство и типоразмер: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600: XXL ECO 1150; Тип: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600: XXL ECO 1150
Размеры - Смещение водяного соединителя: 0 mm; Объем: 4.68845 m3; Смещение фланца: 45 mm
Стадии - Стадия возведения: Стадия 1

# IfcEnergyConversionDevice: XXL ECO 1300, BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600:XXL ECO 1300:655994
In: Этаж 01
Type - PredefinedType: WATER; Material: Color RGB 120-120-120, Color RGB 216-216-216, Color RGB 255-255-240, Color RGB 181-181-181, Color RGB 100-100-100, Color RGB 049-049-049
Type - Видимость - Газ_Фланец: yes
Type - Графика - Зона обслуживания_Глубина_Задняя часть: 450 mm; Зона обслуживания_Глубина_Левая сторона: 800 mm; Зона обслуживания_Глубина_Лицевая часть: 1000 mm; Зона обслуживания_Глубина_Правая сторона: 450 mm; Привязка_Зона обслуживания_Задняя часть: 710 mm
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: ELCO; ADSK_Код изделия: 3581763; ADSK_Марка: TRIGON XXL ECO 1300; ADSK_Наименование: Водотрубный премиксный конденсационный котел TRIGON XXL ECO, 1255 кВт, максимальное давление 8 Бар; ELCO_Страна производства: Нидерланды
Type - Идентификация - ADSK_URL документации изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_URL страницы изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.pro/manufacturer/company/16987; BL_Email: support@ru.elco.net; BL_Разработано: support@bimlib.pro; URL: https://elco.net.ru/; Заголовок OmniClass: Hot Water Heat Generators; Изготовитель: ELCO Heating Solutions; Имя типа: XXL ECO 1300; Номер OmniClass: 23.75.10.11.14; Описание: Высокоэффективные водотрубные премиксные котлы TRIGON XXL с уникальной модулируемой водоохлаждаемой горелкой. TRIGON XXL ECO – конденсационные котлы с эффективностью до 104,1 %
Type - Механизмы - Гидравлическое сопротивление при номинальном расходе ΔT=20: 54000 Pa; Давление воды макс: 800000 Pa; Давление воды мин: 150000 Pa; Максимальная рабочая температура: 90 kg/K/s3; Максимальная разница температур между подающей и обратной линией: 30 kg/K/s3; Номинальный расход при ΔT=20: 0.015 m3/s; Объем воды: 0.109 m3
Type - Механизмы - Нагрузки - Минимальная тепловая мощность при 50⁄30 ⁰С: 359000 W; Минимальная тепловая мощность при 80⁄60 ⁰С: 356000 W; Номинальная тепловая мощность при 50⁄30 ⁰С: 1297000 W; Номинальная тепловая мощность при 80⁄60 ⁰С: 1255000 W; Номинальная тепловая нагрузка макс: 1333000 W; Номинальная тепловая нагрузка мин: 381000 W; Эффективность на макс при 50⁄30 ⁰С: 0.949; Эффективность на макс при 80⁄60 ⁰С: 0.941; Эффективность на мин при 50⁄30 ⁰С: 1.029; Эффективность на мин при 80⁄60 ⁰С: 0.934
Type - Механизмы - Расход - Максимальное давление газа: 10000 Pa; Максимальный расход газа: 0.0397979 m3/s; Минимальное давление природного газа G20: 3500 Pa; Минимальное давление природного газа G25: 3500 Pa; Минимальное давление СУГ G31: 5000 Pa; Минимальный расход газа: 0.0113751 m3/s; Номинальное давление природного газа G20: 3500 Pa; Номинальное давление природного газа G25: 3500 Pa; Номинальное давление СУГ G31: 5000 Pa; Фактическая калорийность газа: 8000
Type - Прочее - Категория: Оборудование; Имя семейства: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600; Максимальный объемный расход конденсата: 15,9 Л/с; Максимальный остаточный напор дымовых газов после котла: 150 Pa; Максимальный уровень CO: 4 мг/кВт∙ч; Максимальный уровень NOx: 37 мг/кВт∙ч; Макс температура дымовых газов при 80⁄60 ⁰С: 153 kg/K/s3; Массовый расход дымовых газов макс: 2119 кг/ч; Массовый расход дымовых газов мин: 660 кг/ч; Объемный расход дымовых газов макс: 0.71 m3/s; Объемный расход дымовых газов мин: 0.171111 m3/s
Type - Размеры - Горелка 1: no; Горелка 2: yes; Соединитель 1: no; Соединитель 2: yes; Соединитель 2 Длина: 0 mm; ADSK_Размер_Высота: 1575 mm; ADSK_Размер_Глубина: 3310 mm; ADSK_Размер_Ширина: 1370 mm; B1: 1250 mm; B2: 685 mm; B3: 145 mm; B4: 1160 mm; B5: 145 mm; B6: 1105 mm; D: 450 mm; G: 76 mm; H1: 915 mm; H2: 435 mm; H3: 490 mm; H4: 260 mm; L1: 480 mm; L2: 1550 mm; L3: 350 mm; L4: 230 mm; L5: 710 mm; LW: 185 mm; W: 89 mm; Высота G: 435 mm; Высота W: 260 mm; Высота дымовых газов: 490 mm; Высота слива: 161 mm; Глубина блока: 2600 mm; Диаметр компенсатора: 270 mm; Длина 1_1: 512 mm; Длина 1_2: 679.5 mm; Длина 1_3: 679.5 mm; Длина 2_1: 512 mm; Длина 2_2: 968 mm; Длина 2_З: 1 mm; Длина 3_1: 2448 mm; Длина 3_2: 1 mm; Длина отрезка: 325 mm; Подключение воды: 80 mm; Подключение газа: 65 mm; Подключение дымохода: 450 mm; Подключение забора воздуха_для внешнего забора: 450 mm; Подключение слива конденсата: 40 mm; Радиус компенсатора: 137 mm; Служебная подрезка: 18 mm; Смещение: 94 mm; Смещение ножек: 1324 mm; Смещение соединения воды: 1225 mm; Соединитель 1 Длина: 480 mm; Ширина G: 1250 mm; Ширина W: 145 mm; Ширина дымовых газов: 350 mm; Ширина полки Горелки: 770 mm; Ширина слива: 105 mm
Type - Силы - Уровень звуковой мощности: 68.7 дБ(А)
Type - Текст - ADSK_Масса: 1740
Type - Электросети - Класс защиты от поражения электрическим током: IP00; Потребляемая котлом электрическая мощность макс: 2330 W; Потребляемая котлом электрическая мощность мин: 585 W; Предохранитель: 16 A; Частота: 50 Hz
Type - Электросети - Нагрузки - ADSK_Количество фаз: 1; ADSK_Напряжение: 400 V
Видимость - Зона обслуживания: no; Контрфланец: no
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 43
Механизмы - ELCO_Слив: 0; ADSK_Расход воздуха приточный: 0 m3/s; ADSK_Расход жидкости: 0 m3/s; ELCO_Отвод дымовых газов: 0 m3/s; ELCO_Расход газа: 0 m3/s; Классификация систем: Приточный воздух,Мощность,Не определено,Обратная жидкость,Приточная жидкость,Канализация,Отработанный воздух
Прочее - Код типа: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600: XXL ECO 1300; Семейство: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600: XXL ECO 1300; Семейство и типоразмер: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600: XXL ECO 1300; Тип: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600: XXL ECO 1300
Размеры - Смещение водяного соединителя: 0 mm; Объем: 5.16991 m3; Смещение фланца: 45 mm
Стадии - Стадия возведения: Стадия 1

# IfcEnergyConversionDevice: XXL ECO 1450, BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600:XXL ECO 1450:656002
In: Этаж 01
Type - PredefinedType: WATER; Material: Color RGB 120-120-120, Color RGB 216-216-216, Color RGB 255-255-240, Color RGB 181-181-181, Color RGB 100-100-100, Color RGB 049-049-049
Type - Видимость - Газ_Фланец: yes
Type - Графика - Зона обслуживания_Глубина_Задняя часть: 450 mm; Зона обслуживания_Глубина_Левая сторона: 800 mm; Зона обслуживания_Глубина_Лицевая часть: 1000 mm; Зона обслуживания_Глубина_Правая сторона: 450 mm; Привязка_Зона обслуживания_Задняя часть: 710 mm
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: ELCO; ADSK_Код изделия: 3581764; ADSK_Марка: TRIGON XXL ECO 1450; ADSK_Наименование: Водотрубный премиксный конденсационный котел TRIGON XXL ECO, 1411 кВт, максимальное давление 8 Бар; ELCO_Страна производства: Нидерланды
Type - Идентификация - ADSK_URL документации изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_URL страницы изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.pro/manufacturer/company/16987; BL_Email: support@ru.elco.net; BL_Разработано: support@bimlib.pro; URL: https://elco.net.ru/; Заголовок OmniClass: Hot Water Heat Generators; Изготовитель: ELCO Heating Solutions; Имя типа: XXL ECO 1450; Номер OmniClass: 23.75.10.11.14; Описание: Высокоэффективные водотрубные премиксные котлы TRIGON XXL с уникальной модулируемой водоохлаждаемой горелкой. TRIGON XXL ECO – конденсационные котлы с эффективностью до 104,1 %
Type - Механизмы - Гидравлическое сопротивление при номинальном расходе ΔT=20: 77000 Pa; Давление воды макс: 800000 Pa; Давление воды мин: 150000 Pa; Максимальная рабочая температура: 90 kg/K/s3; Максимальная разница температур между подающей и обратной линией: 30 kg/K/s3; Номинальный расход при ΔT=20: 0.0169444 m3/s; Объем воды: 0.116 m3
Type - Механизмы - Нагрузки - Минимальная тепловая мощность при 50⁄30 ⁰С: 410000 W; Минимальная тепловая мощность при 80⁄60 ⁰С: 400000 W; Номинальная тепловая мощность при 50⁄30 ⁰С: 1482000 W; Номинальная тепловая мощность при 80⁄60 ⁰С: 1411000 W; Номинальная тепловая нагрузка макс: 1499000 W; Номинальная тепловая нагрузка мин: 428000 W; Эффективность на макс при 50⁄30 ⁰С: 0.949; Эффективность на макс при 80⁄60 ⁰С: 0.941; Эффективность на мин при 50⁄30 ⁰С: 1.029; Эффективность на мин при 80⁄60 ⁰С: 0.934
Type - Механизмы - Расход - Максимальное давление газа: 10000 Pa; Максимальный расход газа: 0.044754 m3/s; Минимальное давление природного газа G20: 3500 Pa; Минимальное давление природного газа G25: 3500 Pa; Минимальное давление СУГ G31: 5000 Pa; Минимальный расход газа: 0.0127783 m3/s; Номинальное давление природного газа G20: 3500 Pa; Номинальное давление природного газа G25: 3500 Pa; Номинальное давление СУГ G31: 5000 Pa; Фактическая калорийность газа: 8000
Type - Прочее - Категория: Оборудование; Имя семейства: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600; Максимальный объемный расход конденсата: 18 Л/ч; Максимальный остаточный напор дымовых газов после котла: 150 Pa; Максимальный уровень CO: 4 мг/кВт∙ч; Максимальный уровень NOx: 37 мг/кВт∙ч; Макс температура дымовых газов при 80⁄60 ⁰С: 153 kg/K/s3; Массовый расход дымовых газов макс: 2383 кг/ч; Массовый расход дымовых газов мин: 741 кг/ч; Объемный расход дымовых газов макс: 0.798333 m3/s; Объемный расход дымовых газов мин: 0.192222 m3/s
Type - Размеры - Соединитель 1: yes; Соединитель 1 Длина: 0 mm; Соединитель 2: no; Горелка 1: no; Горелка 2: yes; Смещение ножек: 1524 mm; ADSK_Размер_Высота: 1575 mm; ADSK_Размер_Глубина: 3310 mm; ADSK_Размер_Ширина: 1570 mm; B1: 1375 mm; B2: 785 mm; B3: 195 mm; B4: 1360 mm; B5: 190 mm; B6: 1180 mm; D: 500 mm; G: 89 mm; H1: 915 mm; H2: 260 mm; H3: 490 mm; H4: 440 mm; L1: 480 mm; L2: 1550 mm; L3: 350 mm; L4: 150 mm; L5: 710 mm; LW: 185 mm; W: 89 mm; Высота G: 440 mm; Высота W: 260 mm; Высота дымовых газов: 490 mm; Высота слива: 161 mm; Глубина блока: 2600 mm; Диаметр компенсатора: 270 mm; Длина 1_1: 512 mm; Длина 1_2: 679.5 mm; Длина 1_3: 679.5 mm; Длина 2_1: 512 mm; Длина 2_2: 968 mm; Длина 2_З: 1 mm; Длина 3_1: 2448 mm; Длина 3_2: 1 mm; Длина отрезка: 325 mm; Подключение воды: 80 mm; Подключение газа: 80 mm; Подключение дымохода: 500 mm; Подключение забора воздуха_для внешнего забора: 450 mm; Подключение слива конденсата: 40 mm; Радиус компенсатора: 137 mm; Служебная подрезка: 18 mm; Смещение: 94 mm; Смещение соединения воды: 1225 mm; Соединитель 2 Длина: 480 mm; Ширина G: 190 mm; Ширина W: 1375 mm; Ширина дымовых газов: 350 mm; Ширина полки Горелки: 769.9 mm; Ширина слива: 105 mm
Type - Силы - Уровень звуковой мощности: 68.7 дБ(А)
Type - Текст - ADSK_Масса: 1899
Type - Электросети - Класс защиты от поражения электрическим током: IP00; Потребляемая котлом электрическая мощность макс: 2770 W; Потребляемая котлом электрическая мощность мин: 695 W; Предохранитель: 16 A; Частота: 50 Hz
Type - Электросети - Нагрузки - ADSK_Количество фаз: 1; ADSK_Напряжение: 400 V
Видимость - Зона обслуживания: no; Контрфланец: no
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 44
Механизмы - ELCO_Слив: 0; ADSK_Расход воздуха приточный: 0 m3/s; ADSK_Расход жидкости: 0 m3/s; ELCO_Отвод дымовых газов: 0 m3/s; ELCO_Расход газа: 0 m3/s; Классификация систем: Приточный воздух,Мощность,Не определено,Обратная жидкость,Приточная жидкость,Канализация,Отработанный воздух
Прочее - Код типа: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600: XXL ECO 1450; Семейство: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600: XXL ECO 1450; Семейство и типоразмер: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600: XXL ECO 1450; Тип: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600: XXL ECO 1450
Размеры - Смещение водяного соединителя: 0 mm; Объем: 5.89454 m3; Смещение фланца: 45 mm
Стадии - Стадия возведения: Стадия 1

# IfcEnergyConversionDevice: XXL ECO 1600, BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600:XXL ECO 1600:656010
In: Этаж 01
Type - PredefinedType: WATER; Material: Color RGB 120-120-120, Color RGB 216-216-216, Color RGB 255-255-240, Color RGB 181-181-181, Color RGB 100-100-100, Color RGB 049-049-049
Type - Видимость - Газ_Фланец: yes
Type - Графика - Зона обслуживания_Глубина_Задняя часть: 450 mm; Зона обслуживания_Глубина_Левая сторона: 800 mm; Зона обслуживания_Глубина_Лицевая часть: 1000 mm; Зона обслуживания_Глубина_Правая сторона: 450 mm; Привязка_Зона обслуживания_Задняя часть: 710 mm
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: ELCO; ADSK_Код изделия: 3581765; ADSK_Марка: TRIGON XXL ECO 1600; ADSK_Наименование: Водотрубный премиксный конденсационный котел TRIGON XXL ECO, 1568 кВт, максимальное давление 8 Бар; ELCO_Страна производства: Нидерланды
Type - Идентификация - ADSK_URL документации изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_URL страницы изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.pro/manufacturer/company/16987; BL_Email: support@ru.elco.net; BL_Разработано: support@bimlib.pro; URL: https://elco.net.ru/; Заголовок OmniClass: Hot Water Heat Generators; Изготовитель: ELCO Heating Solutions; Имя типа: XXL ECO 1600; Номер OmniClass: 23.75.10.11.14; Описание: Высокоэффективные водотрубные премиксные котлы TRIGON XXL с уникальной модулируемой водоохлаждаемой горелкой. TRIGON XXL ECO – конденсационные котлы с эффективностью до 104,1 %
Type - Механизмы - Гидравлическое сопротивление при номинальном расходе ΔT=20: 107000 Pa; Давление воды макс: 800000 Pa; Давление воды мин: 150000 Pa; Максимальная рабочая температура: 90 kg/K/s3; Максимальная разница температур между подающей и обратной линией: 30 kg/K/s3; Номинальный расход при ΔT=20: 0.0186111 m3/s; Объем воды: 0.123 m3
Type - Механизмы - Нагрузки - Минимальная тепловая мощность при 50⁄30 ⁰С: 462000 W; Минимальная тепловая мощность при 80⁄60 ⁰С: 445000 W; Номинальная тепловая мощность при 50⁄30 ⁰С: 1667000 W; Номинальная тепловая мощность при 80⁄60 ⁰С: 1568000 W; Номинальная тепловая нагрузка макс: 1666000 W; Номинальная тепловая нагрузка мин: 476000 W; Эффективность на макс при 50⁄30 ⁰С: 0.949; Эффективность на макс при 80⁄60 ⁰С: 0.941; Эффективность на мин при 50⁄30 ⁰С: 1.029; Эффективность на мин при 80⁄60 ⁰С: 0.934
Type - Механизмы - Расход - Максимальное давление газа: 10000 Pa; Максимальный расход газа: 0.0497399 m3/s; Минимальное давление природного газа G20: 3500 Pa; Минимальное давление природного газа G25: 3500 Pa; Минимальное давление СУГ G31: 5000 Pa; Минимальный расход газа: 0.0142114 m3/s; Номинальное давление природного газа G20: 3500 Pa; Номинальное давление природного газа G25: 3500 Pa; Номинальное давление СУГ G31: 5000 Pa; Фактическая калорийность газа: 8000
Type - Прочее - Категория: Оборудование; Имя семейства: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600; Максимальный объемный расход конденсата: 20 Л/ч; Максимальный остаточный напор дымовых газов после котла: 150 Pa; Максимальный уровень CO: 4 мг/кВт∙ч; Максимальный уровень NOx: 37 мг/кВт∙ч; Макс температура дымовых газов при 80⁄60 ⁰С: 153 kg/K/s3; Массовый расход дымовых газов макс: 2648 кг/ч; Массовый расход дымовых газов мин: 824 кг/ч; Объемный расход дымовых газов макс: 0.887222 m3/s; Объемный расход дымовых газов мин: 0.213889 m3/s
Type - Размеры - Соединитель 1: yes; Соединитель 1 Длина: 0 mm; Соединитель 2: no; Горелка 1: no; Горелка 2: yes; Смещение ножек: 1524 mm; ADSK_Размер_Высота: 1575 mm; ADSK_Размер_Глубина: 3310 mm; ADSK_Размер_Ширина: 1570 mm; B1: 1425 mm; B2: 785 mm; B3: 145 mm; B4: 1360 mm; B5: 140 mm; B6: 1280 mm; D: 500 mm; G: 89 mm; H1: 915 mm; H2: 260 mm; H3: 490 mm; H4: 440 mm; L1: 480 mm; L2: 1550 mm; L3: 350 mm; L4: 150 mm; L5: 710 mm; LW: 185 mm; W: 89 mm; Высота G: 440 mm; Высота W: 260 mm; Высота дымовых газов: 490 mm; Высота слива: 161 mm; Глубина блока: 2600 mm; Диаметр компенсатора: 300 mm; Длина 1_1: 512 mm; Длина 1_2: 679.5 mm; Длина 1_3: 679.5 mm; Длина 2_1: 512 mm; Длина 2_2: 968 mm; Длина 2_З: 1 mm; Длина 3_1: 2448 mm; Длина 3_2: 1 mm; Длина отрезка: 325 mm; Подключение воды: 80 mm; Подключение газа: 80 mm; Подключение дымохода: 500 mm; Подключение забора воздуха_для внешнего забора: 450 mm; Подключение слива конденсата: 40 mm; Радиус компенсатора: 152 mm; Служебная подрезка: 18 mm; Смещение: 94 mm; Смещение соединения воды: 1225 mm; Соединитель 2 Длина: 480 mm; Ширина G: 140 mm; Ширина W: 1425 mm; Ширина дымовых газов: 350 mm; Ширина полки Горелки: 865.4 mm; Ширина слива: 105 mm
Type - Силы - Уровень звуковой мощности: 68.7 дБ(А)
Type - Текст - ADSK_Масса: 1991
Type - Электросети - Класс защиты от поражения электрическим током: IP00; Потребляемая котлом электрическая мощность макс: 2770 W; Потребляемая котлом электрическая мощность мин: 695 W; Предохранитель: 16 A; Частота: 50 Hz
Type - Электросети - Нагрузки - ADSK_Количество фаз: 1; ADSK_Напряжение: 400 V
Видимость - Зона обслуживания: no; Контрфланец: no
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 45
Механизмы - ELCO_Слив: 0; ADSK_Расход воздуха приточный: 0 m3/s; ADSK_Расход жидкости: 0 m3/s; ELCO_Отвод дымовых газов: 0 m3/s; ELCO_Расход газа: 0 m3/s; Классификация систем: Приточный воздух,Мощность,Не определено,Обратная жидкость,Приточная жидкость,Канализация,Отработанный воздух
Прочее - Код типа: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600: XXL ECO 1600; Семейство: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600: XXL ECO 1600; Семейство и типоразмер: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600: XXL ECO 1600; Тип: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600: XXL ECO 1600
Размеры - Смещение водяного соединителя: 0 mm; Объем: 5.90668 m3; Смещение фланца: 45 mm
Стадии - Стадия возведения: Стадия 1

# IfcEnergyConversionDevice: XXL ECO 650, BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600:XXL ECO 650:623340
In: Этаж 01
Type - PredefinedType: WATER; Material: Color RGB 120-120-120, Color RGB 216-216-216, Color RGB 255-255-240, Color RGB 181-181-181, Color RGB 100-100-100, Color RGB 049-049-049
Type - Видимость - Газ_Фланец: no
Type - Графика - Зона обслуживания_Глубина_Задняя часть: 450 mm; Зона обслуживания_Глубина_Левая сторона: 800 mm; Зона обслуживания_Глубина_Лицевая часть: 1000 mm; Зона обслуживания_Глубина_Правая сторона: 450 mm; Привязка_Зона обслуживания_Задняя часть: 550 mm
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: ELCO; ADSK_Код изделия: 3581757; ADSK_Марка: TRIGON XXL ECO 650; ADSK_Наименование: Водотрубный премиксный конденсационный котел TRIGON XXL ECO, 615 кВт, максимальное давление 8 Бар; ELCO_Страна производства: Нидерланды
Type - Идентификация - ADSK_URL документации изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_URL страницы изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.pro/manufacturer/company/16987; BL_Email: support@ru.elco.net; BL_Разработано: support@bimlib.pro; URL: https://elco.net.ru/; Заголовок OmniClass: Hot Water Heat Generators; Изготовитель: ELCO Heating Solutions; Имя типа: XXL ECO 650; Номер OmniClass: 23.75.10.11.14; Описание: Высокоэффективные водотрубные премиксные котлы TRIGON XXL с уникальной модулируемой водоохлаждаемой горелкой. TRIGON XXL ECO – конденсационные котлы с эффективностью до 104,1 %
Type - Механизмы - Гидравлическое сопротивление при номинальном расходе ΔT=20: 39000 Pa; Давление воды макс: 800000 Pa; Давление воды мин: 150000 Pa; Максимальная рабочая температура: 90 kg/K/s3; Максимальная разница температур между подающей и обратной линией: 30 kg/K/s3; Номинальный расход при ΔT=20: 0.00722222 m3/s; Объем воды: 0.053 m3
Type - Механизмы - Нагрузки - Минимальная тепловая мощность при 50⁄30 ⁰С: 181000 W; Минимальная тепловая мощность при 80⁄60 ⁰С: 175000 W; Номинальная тепловая мощность при 50⁄30 ⁰С: 650000 W; Номинальная тепловая мощность при 80⁄60 ⁰С: 615000 W; Номинальная тепловая нагрузка макс: 653000 W; Номинальная тепловая нагрузка мин: 187000 W; Эффективность на макс при 50⁄30 ⁰С: 0.949; Эффективность на макс при 80⁄60 ⁰С: 0.941; Эффективность на мин при 50⁄30 ⁰С: 1.029; Эффективность на мин при 80⁄60 ⁰С: 0.934
Type - Механизмы - Расход - Максимальное давление газа: 10000 Pa; Максимальный расход газа: 0.0194959 m3/s; Минимальное давление природного газа G20: 1700 Pa; Минимальное давление природного газа G25: 2000 Pa; Минимальное давление СУГ G31: 3000 Pa; Минимальный расход газа: 0.00558305 m3/s; Номинальное давление природного газа G20: 2000 Pa; Номинальное давление природного газа G25: 2500 Pa; Номинальное давление СУГ G31: 3000 Pa; Фактическая калорийность газа: 8000
Type - Прочее - Категория: Оборудование; Имя семейства: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600; Максимальный объемный расход конденсата: 7.8 Л/ч; Максимальный остаточный напор дымовых газов после котла: 150 Pa; Максимальный уровень CO: 4 мг/кВт∙ч; Максимальный уровень NOx: 37 мг/кВт∙ч; Макс температура дымовых газов при 80⁄60 ⁰С: 153 kg/K/s3; Массовый расход дымовых газов макс: 1038 кг/ч; Массовый расход дымовых газов мин: 324 кг/ч; Объемный расход дымовых газов макс: 0.347778 m3/s; Объемный расход дымовых газов мин: 0.0841667 m3/s
Type - Размеры - ADSK_Размер_Высота: 1555 mm; ADSK_Размер_Глубина: 2185 mm; ADSK_Размер_Ширина: 1370 mm; B1: 1235 mm; B2: 685 mm; B3: 135 mm; B4: 1160 mm; B5: 100 mm; B6: 1100 mm; D: 350 mm; G: 60 mm; H1: 960 mm; H2: 660 mm; H3: 530 mm; H4: 480 mm; L1: 475 mm; L2: 660 mm; L3: 260 mm; L4: 110 mm; L5: 550 mm; LW: 185 mm; W: 76 mm; Высота G: 480 mm; Высота W: 660 mm; Высота дымовых газов: 530 mm; Высота слива: 272 mm; Глубина блока: 1710 mm; Горелка 1: yes; Горелка 2: no; Диаметр компенсатора: 200 mm; Длина 1_1: 678.5 mm; Длина 1_2: 1 mm; Длина 1_3: 1 mm; Длина 2_1: 1558 mm; Длина 2_2: 1 mm; Длина 2_З: 1 mm; Длина 3_1: 1558 mm; Длина 3_2: 1 mm; Длина отрезка: 419 mm; Подключение воды: 65 mm; Подключение газа: 50 mm; Подключение дымохода: 350 mm; Подключение забора воздуха_для внешнего забора: 355 mm; Подключение слива конденсата: 40 mm; Радиус компенсатора: 102 mm; Служебная подрезка: 18 mm; Смещение: 94 mm; Смещение ножек: 1324 mm; Смещение соединения воды: 1225 mm; Соединитель 1: yes; Соединитель 1 Длина: 0 mm; Соединитель 2: no; Соединитель 2 Длина: 475 mm; Ширина G: 100 mm; Ширина W: 1235 mm; Ширина дымовых газов: 260 mm; Ширина полки Горелки: 860 mm; Ширина слива: 645 mm
Type - Силы - Уровень звуковой мощности: 68.7 дБ(А)
Type - Текст - ADSK_Масса: 844
Type - Электросети - Класс защиты от поражения электрическим током: IP00; Потребляемая котлом электрическая мощность макс: 900 W; Потребляемая котлом электрическая мощность мин: 225 W; Предохранитель: 16 A; Частота: 50 Hz
Type - Электросети - Нагрузки - ADSK_Количество фаз: 1; ADSK_Напряжение: 400 V
Видимость - Зона обслуживания: no; Контрфланец: no
Зависимости - Основа: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 29
Механизмы - ADSK_Расход воздуха приточный: 0 m3/s; ADSK_Расход жидкости: 0 m3/s; ELCO_Отвод дымовых газов: 0 m3/s; ELCO_Расход газа: 0 m3/s; ELCO_Слив: 0; Классификация систем: Приточный воздух,Мощность,Не определено,Обратная жидкость,Приточная жидкость,Канализация,Отработанный воздух
Прочее - Код типа: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600: XXL ECO 650; Семейство: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600: XXL ECO 650; Семейство и типоразмер: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600: XXL ECO 650; Тип: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600: XXL ECO 650
Размеры - Объем: 3.36054 m3; Смещение водяного соединителя: 0 mm; Смещение фланца: 45 mm
Стадии - Стадия возведения: Стадия 1

# IfcEnergyConversionDevice: XXL ECO 750, BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600:XXL ECO 750:655952
In: Этаж 01
Type - PredefinedType: WATER; Material: Color RGB 120-120-120, Color RGB 216-216-216, Color RGB 255-255-240, Color RGB 181-181-181, Color RGB 100-100-100, Color RGB 049-049-049
Type - Видимость - Газ_Фланец: no
Type - Графика - Зона обслуживания_Глубина_Задняя часть: 450 mm; Зона обслуживания_Глубина_Левая сторона: 800 mm; Зона обслуживания_Глубина_Лицевая часть: 1000 mm; Зона обслуживания_Глубина_Правая сторона: 450 mm; Привязка_Зона обслуживания_Задняя часть: 550 mm
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: ELCO; ADSK_Код изделия: 3581758; ADSK_Марка: TRIGON XXL ECO 750; ADSK_Наименование: Водотрубный премиксный конденсационный котел TRIGON XXL ECO, 719 кВт, максимальное давление 8 Бар; ELCO_Страна производства: Нидерланды
Type - Идентификация - ADSK_URL документации изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_URL страницы изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.pro/manufacturer/company/16987; BL_Email: support@ru.elco.net; BL_Разработано: support@bimlib.pro; URL: https://elco.net.ru/; Заголовок OmniClass: Hot Water Heat Generators; Изготовитель: ELCO Heating Solutions; Имя типа: XXL ECO 750; Номер OmniClass: 23.75.10.11.14; Описание: Высокоэффективные водотрубные премиксные котлы TRIGON XXL с уникальной модулируемой водоохлаждаемой горелкой. TRIGON XXL ECO – конденсационные котлы с эффективностью до 104,1 %
Type - Механизмы - Гидравлическое сопротивление при номинальном расходе ΔT=20: 24000 Pa; Давление воды макс: 800000 Pa; Давление воды мин: 150000 Pa; Максимальная рабочая температура: 90 kg/K/s3; Максимальная разница температур между подающей и обратной линией: 30 kg/K/s3; Номинальный расход при ΔT=20: 0.00861111 m3/s; Объем воды: 0.07 m3
Type - Механизмы - Нагрузки - Минимальная тепловая мощность при 50⁄30 ⁰С: 201000 W; Минимальная тепловая мощность при 80⁄60 ⁰С: 204000 W; Номинальная тепловая мощность при 50⁄30 ⁰С: 726000 W; Номинальная тепловая мощность при 80⁄60 ⁰С: 719000 W; Номинальная тепловая нагрузка макс: 764000 W; Номинальная тепловая нагрузка мин: 218000 W; Эффективность на макс при 50⁄30 ⁰С: 0.949; Эффективность на макс при 80⁄60 ⁰С: 0.941; Эффективность на мин при 50⁄30 ⁰С: 1.029; Эффективность на мин при 80⁄60 ⁰С: 0.934
Type - Механизмы - Расход - Максимальное давление газа: 10000 Pa; Максимальный расход газа: 0.0228099 m3/s; Минимальное давление природного газа G20: 1700 Pa; Минимальное давление природного газа G25: 2000 Pa; Минимальное давление СУГ G31: 3000 Pa; Минимальный расход газа: 0.00650859 m3/s; Номинальное давление природного газа G20: 2000 Pa; Номинальное давление природного газа G25: 2500 Pa; Номинальное давление СУГ G31: 3000 Pa; Фактическая калорийность газа: 8000
Type - Прочее - Категория: Оборудование; Имя семейства: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600; Максимальный объемный расход конденсата: 9.1 Л/ч; Максимальный остаточный напор дымовых газов после котла: 150 Pa; Максимальный уровень CO: 4 мг/кВт∙ч; Максимальный уровень NOx: 37 мг/кВт∙ч; Макс температура дымовых газов при 80⁄60 ⁰С: 153 kg/K/s3; Массовый расход дымовых газов макс: 1214 кг/ч; Массовый расход дымовых газов мин: 377 кг/ч; Объемный расход дымовых газов макс: 0.406944 m3/s; Объемный расход дымовых газов мин: 0.0980556 m3/s
Type - Размеры - Горелка 1: yes; Горелка 2: no; Соединитель 1: yes; Соединитель 1 Длина: 0 mm; Соединитель 2: no; ADSK_Размер_Высота: 1555 mm; ADSK_Размер_Глубина: 2565 mm; ADSK_Размер_Ширина: 1170 mm; B1: 1025 mm; B2: 585 mm; B3: 145 mm; B4: 960 mm; B5: 150 mm; B6: 880 mm; D: 350 mm; G: 60 mm; H1: 960 mm; H2: 660 mm; H3: 530 mm; H4: 500 mm; L1: 480 mm; L2: 1030 mm; L3: 260 mm; L4: 110 mm; L5: 550 mm; LW: 185 mm; W: 89 mm; Высота G: 500 mm; Высота W: 660 mm; Высота дымовых газов: 530 mm; Высота слива: 272 mm; Глубина блока: 2085 mm; Диаметр компенсатора: 200 mm; Длина 1_1: 678.5 mm; Длина 1_2: 674 mm; Длина 1_3: 1 mm; Длина 2_1: 968 mm; Длина 2_2: 1 mm; Длина 2_З: 1 mm; Длина 3_1: 1933 mm; Длина 3_2: 1 mm; Длина отрезка: 418 mm; Подключение воды: 80 mm; Подключение газа: 50 mm; Подключение дымохода: 350 mm; Подключение забора воздуха_для внешнего забора: 355 mm; Подключение слива конденсата: 40 mm; Радиус компенсатора: 102 mm; Служебная подрезка: 18 mm; Смещение: 94 mm; Смещение ножек: 1124 mm; Смещение соединения воды: 1225 mm; Соединитель 2 Длина: 480 mm; Ширина G: 150 mm; Ширина W: 1025 mm; Ширина дымовых газов: 260 mm; Ширина полки Горелки: 616 mm; Ширина слива: 645 mm
Type - Силы - Уровень звуковой мощности: 68.7 дБ(А)
Type - Текст - ADSK_Масса: 958
Type - Электросети - Класс защиты от поражения электрическим током: IP00; Потребляемая котлом электрическая мощность макс: 900 W; Потребляемая котлом электрическая мощность мин: 320 W; Предохранитель: 16 A; Частота: 50 Hz
Type - Электросети - Нагрузки - ADSK_Количество фаз: 1; ADSK_Напряжение: 400 V
Видимость - Зона обслуживания: no; Контрфланец: no
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 38
Механизмы - ELCO_Слив: 0; ADSK_Расход воздуха приточный: 0 m3/s; ADSK_Расход жидкости: 0 m3/s; ELCO_Отвод дымовых газов: 0 m3/s; ELCO_Расход газа: 0 m3/s; Классификация систем: Приточный воздух,Мощность,Не определено,Обратная жидкость,Приточная жидкость,Канализация,Отработанный воздух
Прочее - Код типа: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600: XXL ECO 750; Семейство: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600: XXL ECO 750; Семейство и типоразмер: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600: XXL ECO 750; Тип: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600: XXL ECO 750
Размеры - Смещение водяного соединителя: 0 mm; Объем: 3.49254 m3; Смещение фланца: 45 mm
Стадии - Стадия возведения: Стадия 1

# IfcEnergyConversionDevice: XXL ECO 850, BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600:XXL ECO 850:655960
In: Этаж 01
Type - PredefinedType: WATER; Material: Color RGB 120-120-120, Color RGB 216-216-216, Color RGB 255-255-240, Color RGB 181-181-181, Color RGB 100-100-100, Color RGB 049-049-049
Type - Видимость - Газ_Фланец: no
Type - Графика - Зона обслуживания_Глубина_Задняя часть: 450 mm; Зона обслуживания_Глубина_Левая сторона: 800 mm; Зона обслуживания_Глубина_Лицевая часть: 1000 mm; Зона обслуживания_Глубина_Правая сторона: 450 mm; Привязка_Зона обслуживания_Задняя часть: 550 mm
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: ELCO; ADSK_Код изделия: 3581759; ADSK_Марка: TRIGON XXL ECO 850; ADSK_Наименование: Водотрубный премиксный конденсационный котел TRIGON XXL ECO, 814 кВт, максимальное давление 8 Бар; ELCO_Страна производства: Нидерланды
Type - Идентификация - ADSK_URL документации изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_URL страницы изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.pro/manufacturer/company/16987; BL_Email: support@ru.elco.net; BL_Разработано: support@bimlib.pro; URL: https://elco.net.ru/; Заголовок OmniClass: Hot Water Heat Generators; Изготовитель: ELCO Heating Solutions; Имя типа: XXL ECO 850; Номер OmniClass: 23.75.10.11.14; Описание: Высокоэффективные водотрубные премиксные котлы TRIGON XXL с уникальной модулируемой водоохлаждаемой горелкой. TRIGON XXL ECO – конденсационные котлы с эффективностью до 104,1 %
Type - Механизмы - Гидравлическое сопротивление при номинальном расходе ΔT=20: 29000 Pa; Давление воды макс: 800000 Pa; Давление воды мин: 150000 Pa; Максимальная рабочая температура: 90 kg/K/s3; Максимальная разница температур между подающей и обратной линией: 30 kg/K/s3; Номинальный расход при ΔT=20: 0.00972222 m3/s; Объем воды: 0.075 m3
Type - Механизмы - Нагрузки - Минимальная тепловая мощность при 50⁄30 ⁰С: 235000 W; Минимальная тепловая мощность при 80⁄60 ⁰С: 231000 W; Номинальная тепловая мощность при 50⁄30 ⁰С: 849000 W; Номинальная тепловая мощность при 80⁄60 ⁰С: 814000 W; Номинальная тепловая нагрузка макс: 865000 W; Номинальная тепловая нагрузка мин: 247000 W; Эффективность на макс при 50⁄30 ⁰С: 0.949; Эффективность на макс при 80⁄60 ⁰С: 0.941; Эффективность на мин при 50⁄30 ⁰С: 1.029; Эффективность на мин при 80⁄60 ⁰С: 0.934
Type - Механизмы - Расход - Максимальное давление газа: 10000 Pa; Максимальный расход газа: 0.0258254 m3/s; Минимальное давление природного газа G20: 1700 Pa; Минимальное давление природного газа G25: 2000 Pa; Минимальное давление СУГ G31: 3000 Pa; Минимальный расход газа: 0.00737441 m3/s; Номинальное давление природного газа G20: 2000 Pa; Номинальное давление природного газа G25: 2500 Pa; Номинальное давление СУГ G31: 3000 Pa; Фактическая калорийность газа: 8000
Type - Прочее - Категория: Оборудование; Имя семейства: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600; Максимальный объемный расход конденсата: 10.3 Л/ч; Максимальный остаточный напор дымовых газов после котла: 150 Pa; Максимальный уровень CO: 4 мг/кВт∙ч; Максимальный уровень NOx: 37 мг/кВт∙ч; Макс температура дымовых газов при 80⁄60 ⁰С: 153 kg/K/s3; Массовый расход дымовых газов макс: 1375 кг/ч; Массовый расход дымовых газов мин: 428 кг/ч; Объемный расход дымовых газов макс: 0.460833 m3/s; Объемный расход дымовых газов мин: 0.111111 m3/s
Type - Размеры - Горелка 1: yes; Горелка 2: no; Соединитель 1: yes; Соединитель 1 Длина: 0 mm; Соединитель 2: no; ADSK_Размер_Высота: 1555 mm; ADSK_Размер_Глубина: 2565 mm; ADSK_Размер_Ширина: 1170 mm; B1: 1075 mm; B2: 585 mm; B3: 95 mm; B4: 960 mm; B5: 100 mm; B6: 980 mm; D: 400 mm; G: 60 mm; H1: 960 mm; H2: 660 mm; H3: 530 mm; H4: 500 mm; L1: 480 mm; L2: 1030 mm; L3: 260 mm; L4: 110 mm; L5: 550 mm; LW: 185 mm; W: 89 mm; Высота G: 500 mm; Высота W: 660 mm; Высота дымовых газов: 530 mm; Высота слива: 272 mm; Глубина блока: 2085 mm; Диаметр компенсатора: 200 mm; Длина 1_1: 678.5 mm; Длина 1_2: 674 mm; Длина 1_3: 1 mm; Длина 2_1: 968 mm; Длина 2_2: 1 mm; Длина 2_З: 1 mm; Длина 3_1: 1933 mm; Длина 3_2: 1 mm; Длина отрезка: 326 mm; Подключение воды: 80 mm; Подключение газа: 50 mm; Подключение дымохода: 400 mm; Подключение забора воздуха_для внешнего забора: 355 mm; Подключение слива конденсата: 40 mm; Радиус компенсатора: 102 mm; Служебная подрезка: 18 mm; Смещение: 94 mm; Смещение ножек: 1124 mm; Смещение соединения воды: 1225 mm; Соединитель 2 Длина: 480 mm; Ширина G: 100 mm; Ширина W: 1075 mm; Ширина дымовых газов: 260 mm; Ширина полки Горелки: 616 mm; Ширина слива: 645 mm
Type - Силы - Уровень звуковой мощности: 68.7 дБ(А)
Type - Текст - ADSK_Масса: 1084
Type - Электросети - Класс защиты от поражения электрическим током: IP00; Потребляемая котлом электрическая мощность макс: 1270 W; Потребляемая котлом электрическая мощность мин: 320 W; Предохранитель: 16 A; Частота: 50 Hz
Type - Электросети - Нагрузки - ADSK_Количество фаз: 1; ADSK_Напряжение: 400 V
Видимость - Зона обслуживания: no; Контрфланец: no
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 39
Механизмы - ELCO_Слив: 0; ADSK_Расход воздуха приточный: 0 m3/s; ADSK_Расход жидкости: 0 m3/s; ELCO_Отвод дымовых газов: 0 m3/s; ELCO_Расход газа: 0 m3/s; Классификация систем: Приточный воздух,Мощность,Не определено,Обратная жидкость,Приточная жидкость,Канализация,Отработанный воздух
Прочее - Код типа: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600: XXL ECO 850; Семейство: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600: XXL ECO 850; Семейство и типоразмер: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600: XXL ECO 850; Тип: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600: XXL ECO 850
Размеры - Смещение водяного соединителя: 0 mm; Объем: 3.49256 m3; Смещение фланца: 45 mm
Стадии - Стадия возведения: Стадия 1

# IfcEnergyConversionDevice: XXL ECO 950, BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600:XXL ECO 950:655968
In: Этаж 01
Type - PredefinedType: WATER; Material: Color RGB 120-120-120, Color RGB 216-216-216, Color RGB 255-255-240, Color RGB 181-181-181, Color RGB 100-100-100, Color RGB 049-049-049
Type - Видимость - Газ_Фланец: yes
Type - Графика - Зона обслуживания_Глубина_Задняя часть: 450 mm; Зона обслуживания_Глубина_Левая сторона: 800 mm; Зона обслуживания_Глубина_Лицевая часть: 1000 mm; Зона обслуживания_Глубина_Правая сторона: 450 mm; Привязка_Зона обслуживания_Задняя часть: 550 mm
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: ELCO; ADSK_Код изделия: 3581760; ADSK_Марка: TRIGON XXL ECO 950; ADSK_Наименование: Водотрубный премиксный конденсационный котел TRIGON XXL ECO, 909 кВт, максимальное давление 8 Бар; ELCO_Страна производства: Нидерланды
Type - Идентификация - ADSK_URL документации изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_URL страницы изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.pro/manufacturer/company/16987; BL_Email: support@ru.elco.net; BL_Разработано: support@bimlib.pro; URL: https://elco.net.ru/; Заголовок OmniClass: Hot Water Heat Generators; Изготовитель: ELCO Heating Solutions; Имя типа: XXL ECO 950; Номер OmniClass: 23.75.10.11.14; Описание: Высокоэффективные водотрубные премиксные котлы TRIGON XXL с уникальной модулируемой водоохлаждаемой горелкой. TRIGON XXL ECO – конденсационные котлы с эффективностью до 104,1 %
Type - Механизмы - Гидравлическое сопротивление при номинальном расходе ΔT=20: 35000 Pa; Давление воды макс: 800000 Pa; Давление воды мин: 150000 Pa; Максимальная рабочая температура: 90 kg/K/s3; Максимальная разница температур между подающей и обратной линией: 30 kg/K/s3; Номинальный расход при ΔT=20: 0.0108333 m3/s; Объем воды: 0.08 m3
Type - Механизмы - Нагрузки - Минимальная тепловая мощность при 50⁄30 ⁰С: 267000 W; Минимальная тепловая мощность при 80⁄60 ⁰С: 258000 W; Номинальная тепловая мощность при 50⁄30 ⁰С: 961000 W; Номинальная тепловая мощность при 80⁄60 ⁰С: 909000 W; Номинальная тепловая нагрузка макс: 966000 W; Номинальная тепловая нагрузка мин: 276000 W; Эффективность на макс при 50⁄30 ⁰С: 0.949; Эффективность на макс при 80⁄60 ⁰С: 0.941; Эффективность на мин при 50⁄30 ⁰С: 1.029; Эффективность на мин при 80⁄60 ⁰С: 0.934
Type - Механизмы - Расход - Максимальное давление газа: 10000 Pa; Максимальный расход газа: 0.0288408 m3/s; Минимальное давление природного газа G20: 1700 Pa; Минимальное давление природного газа G25: 2000 Pa; Минимальное давление СУГ G31: 3000 Pa; Минимальный расход газа: 0.00824023 m3/s; Номинальное давление природного газа G20: 2000 Pa; Номинальное давление природного газа G25: 2500 Pa; Номинальное давление СУГ G31: 3000 Pa; Фактическая калорийность газа: 8000
Type - Прочее - Категория: Оборудование; Имя семейства: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600; Максимальный объемный расход конденсата: 11.5 Л/ч; Максимальный остаточный напор дымовых газов после котла: 150 Pa; Максимальный уровень CO: 4 мг/кВт∙ч; Максимальный уровень NOx: 37 мг/кВт∙ч; Макс температура дымовых газов при 80⁄60 ⁰С: 153 kg/K/s3; Массовый расход дымовых газов макс: 1535 кг/ч; Массовый расход дымовых газов мин: 478 кг/ч; Объемный расход дымовых газов макс: 0.514444 m3/s; Объемный расход дымовых газов мин: 0.124167 m3/s
Type - Размеры - Горелка 1: yes; Горелка 2: no; Соединитель 1: yes; Соединитель 1 Длина: 0 mm; Соединитель 2: no; ADSK_Размер_Высота: 1555 mm; ADSK_Размер_Глубина: 2565 mm; ADSK_Размер_Ширина: 1370 mm; B1: 1225 mm; B2: 685 mm; B3: 145 mm; B4: 1160 mm; B5: 150 mm; B6: 1080 mm; D: 400 mm; G: 76 mm; H1: 960 mm; H2: 660 mm; H3: 530 mm; H4: 500 mm; L1: 480 mm; L2: 1030 mm; L3: 260 mm; L4: 110 mm; L5: 550 mm; LW: 185 mm; W: 89 mm; Высота G: 500 mm; Высота W: 660 mm; Высота дымовых газов: 530 mm; Высота слива: 272 mm; Глубина блока: 2085 mm; Диаметр компенсатора: 250 mm; Длина 1_1: 678.5 mm; Длина 1_2: 674 mm; Длина 1_3: 1 mm; Длина 2_1: 968 mm; Длина 2_2: 1 mm; Длина 2_З: 1 mm; Длина 3_1: 1933 mm; Длина 3_2: 1 mm; Длина отрезка: 326 mm; Подключение воды: 80 mm; Подключение газа: 65 mm; Подключение дымохода: 400 mm; Подключение забора воздуха_для внешнего забора: 355 mm; Подключение слива конденсата: 40 mm; Радиус компенсатора: 127 mm; Служебная подрезка: 18 mm; Смещение: 94 mm; Смещение ножек: 1324 mm; Смещение соединения воды: 1225 mm; Соединитель 2 Длина: 480 mm; Ширина G: 150 mm; Ширина W: 1225 mm; Ширина дымовых газов: 260 mm; Ширина полки Горелки: 697.4 mm; Ширина слива: 645 mm
Type - Силы - Уровень звуковой мощности: 68.7 дБ(А)
Type - Текст - ADSK_Масса: 1221
Type - Электросети - Класс защиты от поражения электрическим током: IP00; Потребляемая котлом электрическая мощность макс: 1270 W; Потребляемая котлом электрическая мощность мин: 320 W; Предохранитель: 16 A; Частота: 50 Hz
Type - Электросети - Нагрузки - ADSK_Количество фаз: 1; ADSK_Напряжение: 400 V
Видимость - Зона обслуживания: no; Контрфланец: no
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 40
Механизмы - ELCO_Слив: 0; ADSK_Расход воздуха приточный: 0 m3/s; ADSK_Расход жидкости: 0 m3/s; ELCO_Отвод дымовых газов: 0 m3/s; ELCO_Расход газа: 0 m3/s; Классификация систем: Приточный воздух,Мощность,Не определено,Обратная жидкость,Приточная жидкость,Канализация,Отработанный воздух
Прочее - Код типа: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600: XXL ECO 950; Семейство: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600: XXL ECO 950; Семейство и типоразмер: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600: XXL ECO 950; Тип: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_ECO_650-1600: XXL ECO 950
Размеры - Смещение водяного соединителя: 0 mm; Объем: 4.07202 m3; Смещение фланца: 45 mm
Стадии - Стадия возведения: Стадия 1
